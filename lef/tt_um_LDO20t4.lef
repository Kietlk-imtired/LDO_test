MACRO sky130_fd_pr__res_xhigh_po_0p35_C4BS3P
  CLASS BLOCK ;
  FOREIGN sky130_fd_pr__res_xhigh_po_0p35_C4BS3P ;
  ORIGIN 0.175 4.705 ;
  SIZE 0.350 BY 9.410 ;
  OBS
      LAYER li1 ;
        RECT -0.175 2.545 0.175 4.705 ;
        RECT -0.175 -4.705 0.175 -2.545 ;
      LAYER met1 ;
        RECT -0.125 2.570 0.125 4.675 ;
        RECT -0.125 -4.675 0.125 -2.570 ;
  END
END sky130_fd_pr__res_xhigh_po_0p35_C4BS3P
END LIBRARY

