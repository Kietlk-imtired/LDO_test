MACRO sky130_fd_pr__res_xhigh_po_0p35_S7EHMZ
  CLASS BLOCK ;
  FOREIGN sky130_fd_pr__res_xhigh_po_0p35_S7EHMZ ;
  ORIGIN 0.175 4.270 ;
  SIZE 0.350 BY 8.540 ;
  OBS
      LAYER li1 ;
        RECT -0.175 2.110 0.175 4.270 ;
        RECT -0.175 -4.270 0.175 -2.110 ;
      LAYER met1 ;
        RECT -0.125 2.135 0.125 4.240 ;
        RECT -0.125 -4.240 0.125 -2.135 ;
  END
END sky130_fd_pr__res_xhigh_po_0p35_S7EHMZ
END LIBRARY

